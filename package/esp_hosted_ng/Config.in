## package/esp_hosted_ng/Config.in
```kconfig
config BR2_PACKAGE_ESP_HOSTED_NG
	bool "esp hosted ng sdio interface"
	default n
	help
		ESP32 HOSTED NG(SDIO)
```
