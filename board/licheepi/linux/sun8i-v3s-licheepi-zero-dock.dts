
#include "sun8i-v3s-licheepi-zero.dts"
#include <dt-bindings/input/input.h>

/ {
	model = "Lichee Pi Zero with Dock";
	compatible = "licheepi,licheepi-zero-dock", "licheepi,licheepi-zero",
		     "allwinner,sun8i-v3s";
	aliases {
		mmc0 = &mmc0;
		mmc1 = &mmc1;
	};

	/*
	leds {
		compatible = "gpio-leds";
		status = "okay";
		green_led {
			label = "green";
			gpios = <&pio 1 4 GPIO_ACTIVE_LOW>; /* PB4 */
			//default-state = "on";
		};

		red_led {
			label = "red";
			gpios = <&pio 1 5 GPIO_ACTIVE_LOW>; /* PB5 */
			//linux,default-trigger = "activity";
		};
		
	}; 
	*/
};

&mmc1 {
	broken-cd;
	bus-width = <4>;
	vmmc-supply = <&reg_vcc3v3>;
	status = "okay";
};

/*
&codec {
	allwinner,audio-routing =
		"Headphone", "HP",
		"Headphone", "HPCOM",
		"MIC1", "Mic",
		"Mic",  "HBIAS";
	status = "okay";
};

&emac {
	phy-handle = <&int_mii_phy>;
	phy-mode = "mii";
	allwinner,leds-active-low;
	status = "okay";
};
*/


&uart1 {
	pinctrl-0 = <&uart1_pins>;
	pinctrl-names = "default";
	status = "okay";
};

&uart2 {
	pinctrl-0 = <&uart2_pins>;
	pinctrl-names = "default";
	status = "okay";
};

&ccu {
	assigned-clocks = <&ccu 18>;
	assigned-clock-parents = <&ccu 9>;
	assigned-clock-rates = <60000000>;
};

&spi0 {
        status ="okay";
        pinctrl-names = "default";
        pinctrl-0 = <&spi0_pins>;
        cs-gpios =   <&pio 2 2 GPIO_ACTIVE_HIGH>, <&pio 1 3 GPIO_ACTIVE_LOW>, <&pio 4 16 GPIO_ACTIVE_LOW>, <&pio 4 19 GPIO_ACTIVE_LOW>;

        mx25l25635e:mx25l25635e@0 {
                compatible = "jedec,spi-nor";
                reg = <0x0>;
                spi-max-frequency = <50000000>;
                #address-cells = <1>;
                #size-cells = <1>;
        };

        icm20600@1 {
                compatible = "rohm,dh2228fv";
                reg = <0x1>;
                spi-max-frequency = <5000000>;
        };
		fpga@2{
                compatible = "rohm,dh2228fv";
                reg = <0x2>;
                spi-max-frequency = <5000000>;
        };

		panel@3 {
			compatible = "sitronix,st7789v";
			reg = <0x3>;
			rotate = <0>;
			spi-cpol;
			spi-cpha;
			rgb;
			fps = <30>;
			buswidth = <8>;
			reset-gpios = <&pio 4 6 GPIO_ACTIVE_LOW>;   // PE6
			dc-gpios = <&pio 4 4 GPIO_ACTIVE_HIGH>;		// PE4
			spi-max-frequency = <32000000>;
			debug = <0>;
			status = "okay";
		};
};

&pwm{
		pinctrl-names = "default";
		pinctrl-0 = <&pwm_pins>;
		status = "okay";
};

/*
&lradc {
	vref-supply = <&reg_vcc3v0>;
	status = "okay";

	button-200 {
		label = "Up";
		linux,code = <KEY_VOLUMEUP>;
		channel = <0>;
		voltage = <200000>;
	};

	button-400 {
		label = "Down";
		linux,code = <KEY_VOLUMEDOWN>;
		channel = <0>;
		voltage = <400000>;
	};

	button-600 {
		label = "Select";
		linux,code = <KEY_SELECT>;
		channel = <0>;
		voltage = <600000>;
	};

	button-800 {
		label = "OK";
		linux,code = <KEY_OK>;
		channel = <0>;
		voltage = <800000>;
	};
};
*/

